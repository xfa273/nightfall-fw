# Repository xfa273/nightfall-fw

## EAGLE design hardware/classic_r1_0/cad/eagle/CM_Nightfall-Air_v1.brd

File hardware/classic_r1_0/cad/README.md:

# classic_r1_0 cad

回路図・基板データの置き場です。

Parts:
BOOT: EG1215AA; SW_EG1215AA
C1, C2, C6, C8, C11, C13: 0.1u; C0402
C3, C5, C12, C17: 2.2u; C0402
C4: 22uF; C0402
C7: 1u; C0402
C9, C10, C16: 10u; C0402
D2, D3: BAS16WT1GW; SOT323
EC_L1, EC_L2, EC_L3, EC_L4: TPB1,27; B1,27
EC_R1, EC_R2, EC_R3, EC_R4: TPB1,27; B1,27
FAN+: TPB1,27; B1,27
FAN-: TPB1,27; B1,27
FT234X: PINHD-1X4; 1X04
IR_LED_FL: LED5MM
IR_LED_FR: LED5MM
IR_LED_L: LED5MM
IR_LED_R: LED5MM
LED1, LED2, LED3: LEDCHIPLED_0603; CHIPLED_0603
MODE: TL6330AF200Q; SW_TL6330AF200Q
MOSFET1: PMPB13XNE,115; DFN2020MD-6_SOT1220_NEX
P2: JST-PH2
P-LED, P-LED2: LEDCHIPLED_0603; CHIPLED_0603
POWER: EG1215AA; SW_EG1215AA
PT_FL: LED5MM
PT_FR: LED5MM
PT_L: LED5MM
PT_R: LED5MM
Q1: SI7135DP-T1-GE3; TRANS_SI7135DP-T1-GE3
R0: 0; R0402
R1, R2, R3, R5, R6, R10, R11, R12: 10k; R0402
R1FL, R1FR, R1L, R1R: 10; R0402
R2FL, R2FR, R20, R21, R22, R23: 470; R0402
R2L, R2R: 680; R0402
R4: 22k; R0402
R7: 100k; R0402
R8: 75k; R0402
R9: 18k; R0402
R13, R25, R26, R27, R28: 1k; R0402
RESET: TL6330AF200Q; SW_TL6330AF200Q
SPK1: SMT-0540-S-R
STM32F405RGT6: STM32F405RGT6; QFP50P1200X1200X160-64N
TP1, TP2, TP3, TP4: TPB1,27; B1,27
TP5, TP6, TP7, TP8, TP9, TP10, TP11: TPTP06R; TP06R
U2, U3: MP6551GQB-P; QFN-14_MP6551_MNP
U4: ISM330DHCXTR; PQFN50P250X300X86-14N
U5: MPM3610GQV-P; CONV_MPM3610GQV-P
U6: I-10673_NJM2884U1-33; NJM2884U1-33
UBUZ: 2N7002TQ-7-F; SOT50P160X90-3N
UFL: 2N7002TQ-7-F; SOT50P160X90-3N
UFR: 2N7002TQ-7-F; SOT50P160X90-3N
UL: 2N7002TQ-7-F; SOT50P160X90-3N
UR: 2N7002TQ-7-F; SOT50P160X90-3N

Connections:
+3V3: BOOT.3, C1.2, C2.1, C3.1, C10.1, C11.1, C17.1, D3.3 (K), EC_L1.TP, EC_R1.TP, PT_FL.A, PT_FR.A, PT_L.A, PT_R.A, R1FL.2, R1FR.2, R1L.2, R1R.2, R3.2, R6.1, R13.2, R20.2, R21.2, R22.2, R23.2, R25.2, SPK1.+ (-), STM32F405RGT6.1 (VBAT), STM32F405RGT6.13 (VDDA), STM32F405RGT6.19 (VDD), STM32F405RGT6.32 (VDD), STM32F405RGT6.48 (VDD), STM32F405RGT6.64 (VDD), TP10.TP, U4.5 (VDD_IO), U4.8 (VDD), U6.4 (VOUT)
+5V: C4.1, C7.1, FT234X.1, R8.2, U5.7 (OUT), U6.1 (CONTROL), U6.5 (VIN)
+12V: C6.1, C8.2, C9.2, C16.1, D2.3 (K), FAN+.TP, Q1.5 (D), R4.2, R7.2, U2.2 (VIN), U3.2 (VIN), U5.16 (IN)
BOOT0: BOOT.2, STM32F405RGT6.60 (BOOT0)
BUZZER: R11.1, STM32F405RGT6.57 (PB5), UBUZ.1 (G)
CS: R6.2, STM32F405RGT6.54 (PD2), TP5.TP, U4.12 (CS)
CS_2: STM32F405RGT6.55 (PB3), TP11.TP
EC_L_A: EC_L4.TP, R21.1, STM32F405RGT6.58 (PB6)
EC_L_B: EC_L3.TP, R20.1, STM32F405RGT6.59 (PB7)
EC_R_A: EC_R4.TP, R23.1, STM32F405RGT6.37 (PC6)
EC_R_B: EC_R3.TP, R22.1, STM32F405RGT6.38 (PC7)
FAN: MOSFET1.3, R10.1, STM32F405RGT6.56 (PB4)
GND: C1.1, C2.2, C3.2, C5.2, C10.2, C11.2, C12.2, C13.2, EC_L2.TP, EC_R2.TP, FT234X.2, LED1.C, LED2.C, LED3.C, MODE.3, MODE.4, P-LED.C, P-LED2.C, R0.2, R1.1, R2.2, R2FL.1, R2FR.1, R2L.1, R2R.1, R5.1, R10.2, R11.2, RESET.3, RESET.4, STM32F405RGT6.12 (VSSA), STM32F405RGT6.18 (VSS), STM32F405RGT6.63 (VSS), TP9.TP, U4.2 (SDX), U4.3 (SCX), U4.6 (GND), U4.7 (GND), UBUZ.2 (E), UFL.2 (E), UFR.2 (E), UL.2 (E), UR.2 (E)
GND2: C4.2, C7.2, C8.1, C9.1, C16.2, C17.2, MOSFET1.4, MOSFET1.8, P2.1, POWER.1, R0.1, R9.2, U2.6 (SR), U2.9 (GND), U3.6 (SR), U3.9 (GND), U5.3 (AGND), U5.12 (PGND), U5.13 (PGND), U5.14 (PGND), U6.2 (GND)
IR_FL: STM32F405RGT6.2 (PC13/RTC_OUT), UFL.1 (G)
IR_FR: STM32F405RGT6.39 (PC8), UFR.1 (G)
IR_L: STM32F405RGT6.3 (PC14/OSC32_IN), UL.1 (G)
IR_R: STM32F405RGT6.40 (PC9), UR.1 (G)
LED_1: R26.2, STM32F405RGT6.50 (PA15)
LED_2: R27.2, STM32F405RGT6.36 (PB15)
LED_3: R28.2, STM32F405RGT6.6 (PH1/OSC_OUT)
MISO: STM32F405RGT6.52 (PC11), TP8.TP, U4.1 (SDO/SA0)
MOSI: STM32F405RGT6.53 (PC12), TP7.TP, U4.14 (SDA)
MOTOR_L_DIR: STM32F405RGT6.23 (PA7/SPI1_MOSI), U3.5 (IN2)
MOTOR_L_OUT1: TP1.TP, U3.1 (OUT1_2), U3.10 (OUT1)
MOTOR_L_OUT2: TP2.TP, U3.3 (OUT2_2), U3.8 (OUT2)
MOTOR_L_PWM: STM32F405RGT6.21 (PA5/SPI1_SCK), U3.13 (IN1)
MOTOR_R_DIR: STM32F405RGT6.29 (PB10), U2.5 (IN2)
MOTOR_R_OUT1: TP3.TP, U2.1 (OUT1_2), U2.10 (OUT1)
MOTOR_R_OUT2: TP4.TP, U2.3 (OUT2_2), U2.8 (OUT2)
MOTOR_R_PWM: STM32F405RGT6.30 (PB11), U2.13 (IN1)
MOTOR_STBY: STM32F405RGT6.11 (PC3/SPI2_MOSI), U2.4 (EN2), U2.14 (EN1), U3.4 (EN2), U3.14 (EN1)
unnamed: P2.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), R12.2
unnamed: IR_LED_FL.K (C), UFL.3 (D)
unnamed: R7.1, U5.17 (EN)
unnamed: P-LED2.A, R13.1
unnamed: R8.1, R9.1, U5.1 (FB)
unnamed: IR_LED_FL.A, R1FL.1
unnamed: IR_LED_L.K (C), UL.3 (D)
unnamed: POWER.2, Q1.4 (G), R12.1
unnamed: C5.1, STM32F405RGT6.47 (VCAP_2)
unnamed: C12.1, STM32F405RGT6.31 (VCAP_1)
unnamed: R1.2, STM32F405RGT6.28 (PB2/BOOT1)
unnamed: IR_LED_L.A, R1L.1
unnamed: IR_LED_FR.K (C), UFR.3 (D)
unnamed: BOOT.1, R2.1
unnamed: C6.2, D2.1 (A), FAN-.TP, MOSFET1.1, MOSFET1.2, MOSFET1.5, MOSFET1.6, MOSFET1.7
unnamed: P-LED.A, R25.1
unnamed: D3.1 (A), SPK1.- (+), UBUZ.3 (D)
unnamed: LED1.A, R26.1
unnamed: IR_LED_FR.A, R1FR.1
unnamed: IR_LED_R.K (C), UR.3 (D)
unnamed: IR_LED_R.A, R1R.1
unnamed: LED2.A, R27.1
unnamed: LED3.A, R28.1
PC_RX: FT234X.4, STM32F405RGT6.42 (PA9)
PC_TX: FT234X.3, STM32F405RGT6.43 (PA10)
PUSH_IN_1: MODE.1, MODE.2, R3.1, STM32F405RGT6.9 (PC1)
PUSH_IN_2: STM32F405RGT6.10 (PC2/SPI2_MISO)
RESET: C13.1, RESET.1, RESET.2, STM32F405RGT6.7 (NRST)
SCK: STM32F405RGT6.51 (PC10), TP6.TP, U4.13 (SCL)
SENSOR_FL: PT_FL.K (C), R2FL.2, STM32F405RGT6.16 (PA2/USART2_TX)
SENSOR_FR: PT_FR.K (C), R2FR.2, STM32F405RGT6.14 (PA0/WKUP)
SENSOR_L: PT_L.K (C), R2L.2, STM32F405RGT6.17 (PA3/USART2_RX)
SENSOR_R: PT_R.K (C), R2R.2, STM32F405RGT6.15 (PA1/USART2_RTS)
SWCL: STM32F405RGT6.49 (PA14/JTCK-SWCLK)
SWDIO: STM32F405RGT6.46 (PA13/JMS-SWDIO)
VCC: U5.2 (VCC)
VOL_CHECK: R4.1, R5.2, STM32F405RGT6.8 (PC0)

Notes on the sheet:
マイコン
インターフェース他
モータ系
センサ系
IMU

Board: 2 copper layers, 50.0 x 86.5 mm, 101 parts (0 on the bottom side), 65 nets.

## EAGLE design hardware/mini_r2_0/cad/eagle/STLink-Adapter.brd

File hardware/mini_r2_0/README.md:

# hardware/mini_r2_0

STM32F413 系 mini 新機体 (`mini_r2_0`) のハードウェア情報です。

## 構成

- `cad/`: Eagle 回路図・基板・PDF・DRC ルール
- `cad/eagle/`: Eagle 移行前原本
- `cad/kicad/`: KiCad 移行後の編集原本
- `cad/export/`: PDF、Gerber、実装位置、発注用出力
- `bom/`: 部品表・調達情報
- `notes/`: ピン一覧、ERC/DRC スクリーンショット

## 備考

- 主要ソースは `_sandbox/f413_preorder/` から本ディレクトリへ移行済みです。
- 以後の更新は `hardware/mini_r2_0/` 側を正として管理します。
- 対応する Eagle プロジェクトは `HM_Nightfall-mini-2e` です。
- 対応するソフトウェア側プロファイルは `f413_preorder` です。
- KiCad 10.0.3 で `cad/kicad/HM_Nightfall-mini-2e/` へ初回インポート済みです。
- 初回インポート結果は `notes/kicad/` の ERC/DRC レポートを確認しながらレビューします。
- KiCad レビュー完了までは Eagle 原本と KiCad 原本を併存させ、確認後に `cad/kicad/` を編集正とします。

## KiCad プロジェクト単位

- `cad/kicad/HM_Nightfall-mini-2e/`: 本体基板
- `cad/kicad/HM_Nightfall-mini-2e_Encoder-PCB-L/`: 左エンコーダ基板
- `cad/kicad/HM_Nightfall-mini-2e_Encoder-PCB-R/`: 右エンコーダ基板
- `cad/kicad/STLink-Adapter/`: ST-LINK から機体コネクタへの変換基板
- `cad/kicad/UART-Adapter/`: UART から機体コネクタへの変換基板
- `cad/kicad/WeAct-Adapter-5V/`: WeAct MiniDebugger用、手動5 V遮断スイッチ付き変換基板

各サブ基板は本体基板と独立した小基板のため、KiCad でも 1 基板 1 プロジェクトとして管理します。
- Eagle 9.6.2 で生成した参照アーカイブは `cad/export/reference/eagle_archive_20260606/` に保存しています。

Parts:
K1: 62201021121
TP1: TP-1X4; 1X04
TP2: TP-1X3; 1X03

Connections:
+3V3: K1.6, TP1.1
+5V: K1.1
BOOT0: K1.7
GND: K1.2, TP1.4
NRST: K1.5
SWCLK: K1.4, TP2.2
SWDIO: K1.3, TP2.1
SWO: K1.10, TP2.3
USART1_RX: K1.9, TP1.2
USART1_TX: K1.8, TP1.3

Board: 2 copper layers, 30.0 x 12.5 mm, 3 parts (1 on the bottom side), 7 nets.

## EAGLE design hardware/mini_r2_0/cad/eagle/UART-Adapter.brd

File hardware/README.md:

# hardware/

このディレクトリは、機体ごとのハードウェア設計情報の正式置き場です。

## ディレクトリ規約

- `hardware/<board_name>/cad/`: 回路図・基板・設計ルール
- `hardware/<board_name>/cad/eagle/`: Eagle 移行前原本
- `hardware/<board_name>/cad/kicad/`: KiCad 移行後の編集原本
- `hardware/<board_name>/cad/export/`: PDF、Gerber、実装位置、発注用出力
- `hardware/<board_name>/bom/`: 部品表・発注情報
- `hardware/<board_name>/notes/`: 設計メモ・確認結果

`board_name` は `mini_r1_0` のように `<family>_r<major>_<minor>` を使用します。

## Git管理方針

- Eagle の `.sch` / `.brd` / `.dru` / `.cam` と KiCad の `.kicad_pro` / `.kicad_sch` / `.kicad_pcb` は原本として管理します。
- Eagle の `.s#1` / `.b#1` / `.l#1` などの自動バックアップと、KiCad のローカル状態・自動バックアップは管理しません。
- 発注用の Gerber zip や PDF は、再現性が必要な発注版だけを `cad/export/` または GitHub Release で管理します。
- Eagle が使えるうちに確保した旧設計の参照アーカイブは `cad/export/reference/eagle_archive_YYYYMMDD/` に置きます。
- 旧設計や大きな archive は現役基板と分け、必要に応じて別リポジトリ化します。

## 現在の公式配置

- `hardware/mini_r2_0/`: `f413_preorder` / STM32F413 搭載ハーフサイズ / Eagle `HM_Nightfall-mini-2e`
- `hardware/mini_r1_0/`: STM32F405 搭載ハーフサイズ最終版 / Eagle `HM_Nightfall-mini_v1`
- `hardware/classic_r1_0/`: STM32F405 搭載クラシックサイズ最終版 / Eagle `CM_Nightfall-Air_v1`

上記以外の Eagle プロジェクトは旧機体の参考資料として扱い、現役基板とは分けて保管します。

`_sandbox/` 配下は実験・一時作業用とし、正式成果物は本ディレクトリに集約します。

Parts:
JP1: PINHD-1X4; 1X04
K2: 62201021121
POWER: EG1218S; EG1218
R1: 10k; R0603

Connections:
+3V3: K2.6
+5V: JP1.1, K2.1, POWER.O
BOOT0: K2.7, POWER.P
GND: JP1.2, K2.2, R1.2
unnamed: POWER.S, R1.1
NRST: K2.5
SWCLK: K2.4
SWDIO: K2.3
SWO: K2.10
USART1_RX: JP1.3, K2.9
USART1_TX: JP1.4, K2.8

Board: 2 copper layers, 30.0 x 12.5 mm, 4 parts (0 on the bottom side), 6 nets.

## EAGLE design hardware/mini_r2_0/cad/eagle/HM_Nightfall-mini-2e_Encoder-PCB-R_v1.brd

Parts:
C2: 0.1u; C0402
EC_R1, EC_R2, EC_R3, EC_R4: PTR1TP06SQ; TP06SQ
IC2: NJL5820R-TE4; NJL5820RTE4
R2: 180; R0402

Connections:
+3V3: C2.1, EC_R1.TP, IC2.5 (VCC), R2.2
EC_R_A: EC_R4.TP, IC2.4 (VOUT1)
EC_R_B: EC_R3.TP, IC2.3 (VOUT2)
GND: C2.2, EC_R2.TP, IC2.1 (CATHODE(LED)), IC2.2 (GND)
unnamed: IC2.6 (ANODE(LED)), R2.1

Board: 2 copper layers, 3.4 x 7.0 mm, 7 parts (1 on the bottom side), 5 nets.

## EAGLE design hardware/mini_r2_0/cad/eagle/HM_Nightfall-mini-2e_Encoder-PCB-L_v1.brd

Parts:
C1: 0.1u; C0402
EC_L1, EC_L2, EC_L3, EC_L4: PTR1TP06SQ; TP06SQ
IC1: NJL5820R-TE4; NJL5820RTE4
R1: 180; R0402

Connections:
+3V3: C1.1, EC_L1.TP, IC1.5 (VCC), R1.2
EC_L_A: EC_L4.TP, IC1.4 (VOUT1)
EC_L_B: EC_L3.TP, IC1.3 (VOUT2)
GND: C1.2, EC_L2.TP, IC1.1 (CATHODE(LED)), IC1.2 (GND)
unnamed: IC1.6 (ANODE(LED)), R1.1

Board: 2 copper layers, 3.4 x 7.0 mm, 7 parts (6 on the bottom side), 5 nets.

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2025 Ultra Librarian. All rights reserved.
pinheader_1m27: Copyright: Würth Elektronik
